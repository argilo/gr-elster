options:
  parameters:
    category: '[Elster]'
    generate_options: hb
    id: elster_channel_rx
    output_language: python
    title: 1-Ch Rx
  states: {}

blocks:
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate/(115000*2*3.1416)
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.05'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: channel_rate * 56.48E-6 / 2
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', pad_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1

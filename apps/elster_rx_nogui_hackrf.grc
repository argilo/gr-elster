<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>908800000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_decimation</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>channel_rate * 35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>corr0</key><value>corr</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>if_gain0</key><value>16</value></param>
<param><key>bb_gain0</key><value>24</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>elster_rx_nogui_hackrf</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>elster_packetize</key>
<param><key>id</key><value>elster_packetize_0</value></param>
<param><key>num_inputs</key><value>25</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_0_1</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_2</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_0_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_1_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_1_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_1</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_1</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0_1_1</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0_0_2</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_0_0_2</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_1_2</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_1_2</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_3</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_3</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0_0_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_0_0_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_1_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_0_1_0_0</value></param>
</block>
<block>
<key>elster_channel_rx</key>
<param><key>id</key><value>elster_channel_rx_1_0_0_1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_7</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_5</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>nchans</key><value>samp_rate / channel_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 175000, 100000, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>ch_map</key><value>[]</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Ch. 15</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Ch. 1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Ch. 31</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Ch. 16</value></param>
</block>
<connection><source_block_id>osmosdr_source_1</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_0_1</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>24</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_2</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_0_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_1_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_1_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_1</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_1</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0_1_1</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0_0_2</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_0_0_2</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_1_2</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_1_2</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_3</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_3</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0_0_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_0_0_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_1_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>elster_channel_rx_0_1_0_0</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>elster_channel_rx_1_0_0_1</source_block_id><sink_block_id>elster_packetize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_6</sink_block_id><source_key>28</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_7</sink_block_id><source_key>29</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_5</sink_block_id><source_key>21</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_2</sink_block_id><source_key>17</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_1</sink_block_id><source_key>16</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_3</sink_block_id><source_key>18</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_4</sink_block_id><source_key>19</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>14</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_0_0_0_0</sink_block_id><source_key>24</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0_1_1</sink_block_id><source_key>34</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0_0_2</sink_block_id><source_key>33</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_0_0_2</sink_block_id><source_key>32</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_1_2</sink_block_id><source_key>31</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_1_2</sink_block_id><source_key>30</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_3</sink_block_id><source_key>27</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0_0_0_0</sink_block_id><source_key>25</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_1_0_0</sink_block_id><source_key>23</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_1_0_0</sink_block_id><source_key>22</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0_0_1</sink_block_id><source_key>20</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_0_1</sink_block_id><source_key>15</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_3</sink_block_id><source_key>26</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_2</sink_block_id><source_key>13</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_1</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_1_0</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_0_0_0_0</sink_block_id><source_key>11</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_0_0_0</sink_block_id><source_key>12</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>elster_channel_rx_1_1_0</sink_block_id><source_key>10</source_key><sink_key>0</sink_key></connection>
</flow_graph>

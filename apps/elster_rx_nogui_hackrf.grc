options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: elster_rx_nogui_hackrf
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '908800000'
  states: {}
- name: channel_decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: corr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: channel_rate * 35
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_4
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_5
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_6
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_7
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: elster_channel_rx_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_3
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_0_1_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_1_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_1_3
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_packetize_0
  id: elster_packetize
  parameters:
    num_inputs: '25'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Ch. 16
  states: {}
- name: note_1
  id: note
  parameters:
    note: Ch. 31
  states: {}
- name: note_2
  id: note
  parameters:
    note: Ch. 1
  states: {}
- name: note_3
  id: note
  parameters:
    note: Ch. 15
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '24'
    corr0: corr
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: samp_rate // channel_rate
    osr: '1.0'
    taps: firdes.low_pass(1, samp_rate, 175000, 100000, firdes.WIN_HAMMING, 6.76)
  states: {}

connections:
- [elster_channel_rx_0, '0', elster_packetize_0, '12']
- [elster_channel_rx_0_0, '0', elster_packetize_0, '13']
- [elster_channel_rx_0_0_0, '0', elster_packetize_0, '17']
- [elster_channel_rx_0_0_0_0, '0', elster_packetize_0, '21']
- [elster_channel_rx_0_0_0_0_0, '0', elster_packetize_0, '3']
- [elster_channel_rx_0_0_0_2, '0', elster_packetize_0, '9']
- [elster_channel_rx_0_0_1, '0', elster_packetize_0, '24']
- [elster_channel_rx_0_1, '0', elster_packetize_0, '15']
- [elster_channel_rx_0_1_0, '0', elster_packetize_0, '19']
- [elster_channel_rx_0_1_0_0, '0', elster_packetize_0, '1']
- [elster_channel_rx_0_1_2, '0', elster_packetize_0, '7']
- [elster_channel_rx_0_2, '0', elster_packetize_0, '23']
- [elster_channel_rx_0_3, '0', elster_packetize_0, '5']
- [elster_channel_rx_1_0, '0', elster_packetize_0, '14']
- [elster_channel_rx_1_0_0, '0', elster_packetize_0, '18']
- [elster_channel_rx_1_0_0_0, '0', elster_packetize_0, '22']
- [elster_channel_rx_1_0_0_0_0, '0', elster_packetize_0, '4']
- [elster_channel_rx_1_0_0_1, '0', elster_packetize_0, '0']
- [elster_channel_rx_1_0_0_2, '0', elster_packetize_0, '10']
- [elster_channel_rx_1_0_1_1, '0', elster_packetize_0, '11']
- [elster_channel_rx_1_1, '0', elster_packetize_0, '16']
- [elster_channel_rx_1_1_0, '0', elster_packetize_0, '20']
- [elster_channel_rx_1_1_0_0, '0', elster_packetize_0, '2']
- [elster_channel_rx_1_1_2, '0', elster_packetize_0, '8']
- [elster_channel_rx_1_3, '0', elster_packetize_0, '6']
- [osmosdr_source_1, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '0', elster_channel_rx_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '10', elster_channel_rx_1_1_0, '0']
- [pfb_channelizer_ccf_0, '11', elster_channel_rx_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '12', elster_channel_rx_1_0_0_0, '0']
- [pfb_channelizer_ccf_0, '13', elster_channel_rx_0_2, '0']
- [pfb_channelizer_ccf_0, '14', blocks_null_sink_1_0, '0']
- [pfb_channelizer_ccf_0, '15', elster_channel_rx_0_0_1, '0']
- [pfb_channelizer_ccf_0, '16', blocks_null_sink_1_1, '0']
- [pfb_channelizer_ccf_0, '17', blocks_null_sink_1_2, '0']
- [pfb_channelizer_ccf_0, '18', blocks_null_sink_1_3, '0']
- [pfb_channelizer_ccf_0, '19', blocks_null_sink_1_4, '0']
- [pfb_channelizer_ccf_0, '2', elster_channel_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '20', elster_channel_rx_1_0_0_1, '0']
- [pfb_channelizer_ccf_0, '21', blocks_null_sink_1_5, '0']
- [pfb_channelizer_ccf_0, '22', elster_channel_rx_0_1_0_0, '0']
- [pfb_channelizer_ccf_0, '23', elster_channel_rx_1_1_0_0, '0']
- [pfb_channelizer_ccf_0, '24', elster_channel_rx_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '25', elster_channel_rx_1_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '26', elster_channel_rx_0_3, '0']
- [pfb_channelizer_ccf_0, '27', elster_channel_rx_1_3, '0']
- [pfb_channelizer_ccf_0, '28', blocks_null_sink_1_6, '0']
- [pfb_channelizer_ccf_0, '29', blocks_null_sink_1_7, '0']
- [pfb_channelizer_ccf_0, '3', elster_channel_rx_1_0, '0']
- [pfb_channelizer_ccf_0, '30', elster_channel_rx_0_1_2, '0']
- [pfb_channelizer_ccf_0, '31', elster_channel_rx_1_1_2, '0']
- [pfb_channelizer_ccf_0, '32', elster_channel_rx_0_0_0_2, '0']
- [pfb_channelizer_ccf_0, '33', elster_channel_rx_1_0_0_2, '0']
- [pfb_channelizer_ccf_0, '34', elster_channel_rx_1_0_1_1, '0']
- [pfb_channelizer_ccf_0, '4', elster_channel_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '5', elster_channel_rx_1_1, '0']
- [pfb_channelizer_ccf_0, '6', elster_channel_rx_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', elster_channel_rx_1_0_0, '0']
- [pfb_channelizer_ccf_0, '8', blocks_null_sink_1, '0']
- [pfb_channelizer_ccf_0, '9', elster_channel_rx_0_1_0, '0']

metadata:
  file_format: 1

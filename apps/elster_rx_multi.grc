options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: elster_rx_multi
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '904600000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: corr
  id: variable_qtgui_range
  parameters:
    label: Freq. correction
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * (channel_rate / 2) / samp_rate
  states: {}
- name: elster_channel_rx_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_0
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_1
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_2
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_3
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_channel_rx_0_4
  id: elster_channel_rx
  parameters: {}
  states: {}
- name: elster_packetize_0
  id: elster_packetize
  parameters:
    num_inputs: '6'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: corr
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: samp_rate // channel_rate
    osr: '1.0'
    taps: firdes.low_pass(1, samp_rate, 175000, 50000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_rotator_cc_0, '0', pfb_channelizer_ccf_0, '0']
- [elster_channel_rx_0, '0', elster_packetize_0, '0']
- [elster_channel_rx_0_0, '0', elster_packetize_0, '1']
- [elster_channel_rx_0_1, '0', elster_packetize_0, '2']
- [elster_channel_rx_0_2, '0', elster_packetize_0, '3']
- [elster_channel_rx_0_3, '0', elster_packetize_0, '4']
- [elster_channel_rx_0_4, '0', elster_packetize_0, '5']
- [osmosdr_source_1, '0', blocks_rotator_cc_0, '0']
- [osmosdr_source_1, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_channelizer_ccf_0, '0', elster_channel_rx_0, '0']
- [pfb_channelizer_ccf_0, '1', elster_channel_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '2', elster_channel_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '3', elster_channel_rx_0_2, '0']
- [pfb_channelizer_ccf_0, '4', elster_channel_rx_0_3, '0']
- [pfb_channelizer_ccf_0, '5', elster_channel_rx_0_4, '0']

metadata:
  file_format: 1
